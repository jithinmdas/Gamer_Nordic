# Keil uVision project ble_app_multilink_central_s120_pca10031.uvprojx, settings and files
target nrf51422_xxac_s120 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s120 +hex
  c flags: Optim=4 OneElfS=1
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S120 BOARD_PCA10031 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT ENABLE_DEBUG_LOG_SUPPORT
  c misc: --c99
  library: MicroLIB
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Application
    ../../../: client_handling.c main.c
  group Documentation
    ../../../: Abstract.txt license.txt
software components: CMSIS:CORE 4.1.0, Board Support:bsp 8.0.0, Device:Startup 7.2.1, nRF_BLE:BLE_Modules:ble_db_discovery 2.0.0, nRF_BLE:BLE_Modules:ble_service_common 2.0.0, nRF_BLE:BLE_Modules:device_manager 2.0.0, nRF_Drivers:app_uart 2.0.0, nRF_Drivers:nrf_delay 2.0.0, nRF_Drivers:nrf_error 2.0.0, nRF_Drivers:nrf_gpio 2.0.0, nRF_Drivers:pstorage 2.0.0, nRF_Libraries:app_error 2.0.0, nRF_Libraries:app_fifo 2.0.0, nRF_Libraries:app_gpiote 2.0.0, nRF_Libraries:app_scheduler 2.0.0, nRF_Libraries:app_trace 2.0.0, nRF_Libraries:app_util 2.0.0, nRF_Libraries:nrf_assert 2.0.0, nRF_Libraries:retarget 2.0.0, nRF_SoftDevice:Internal:sd_common 1.1.2, nRF_SoftDevice:Internal:softdevice_present 1.1.2, nRF_SoftDevice:s120 2.0.0
